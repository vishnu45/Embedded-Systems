#INCLUDE P16F877A.INC
LIST P=16F877A

ORG 0X00
GOTO START
ORG 0X20


START:

BSF STATUS,RP0

MOVLW 0X19
MOVWF SPBRG

MOVLW 0X24
MOVWF TXSTA

BCF STATUS,RP0

BSF RCSTA,SPEN

MOVLW 0X55
MOVWF TXREG

CALL DELAY

MOVLW 0X66
MOVWF TXREG

CALL DELAY

GOTO LOOP

DELAY:
MOVLW 0XFF
MOVWF 0X30

D3:
MOVLW 0X6F
MOVWF 0X31

D2:
MOVLW 0X05
MOVWF 0X32

D1:
DECFSZ 0X32
GOTO D1
DECFSZ 0X31
GOTO D2
DECFSZ 0X30
GOTO D3

RETURN

LOOP:

END
