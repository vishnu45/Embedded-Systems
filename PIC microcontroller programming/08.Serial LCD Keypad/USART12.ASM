#INCLUDE P16F877A.INC
LIST P=16F877A
ORG 0X00
GOTO START
ORG 0X20

;-----------------------------------------------------------
;RECIEVING SERIAL DATA
;-----------------------------------------------------------

START:
BSF STATUS,RP0
CLRF TRISB
BCF STATUS,RP0

MOVF RCREG,0
MOVWF PORTB

MOVLW 0X90
MOVWF RCSTA
BSF STATUS,RP0
MOVLW 0XFF
MOVWF SPBRG
MOVLW 0X04
MOVWF TXSTA
BCF STATUS,RP0
BSF RCSTA,SPEN

OUT:
MOVF RCREG,0
MOVWF PORTB
GOTO OUT

END


